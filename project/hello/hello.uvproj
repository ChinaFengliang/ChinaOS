# Keil uVision project hello.uvproj, settings and files
target ChinaOS(debug) (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: hello
  c flags: Optim=1
  c include: ..\..\ChinaOS\architecture\arm\cortex-m3\nxp\lpc1766\can_repeater;..\..\ChinaOS\architecture\arm\cortex-m3;..\..\ChinaOS\include;..\..\ChinaOS;.\home
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ..\..\ChinaOS\architecture\arm\cortex-m3\nxp\lpc1766\can_repeater\load\debug.scf
  link misc: --entry=main --keep=boot.o(Heap) --keep=boot.o(Stack)
  group architecture
    ../../ChinaOS/architecture/arm/cortex-m3/: boot.s cpu.c syscall.s
    X:/ChinaOS/ChinaOS/architecture/arm/cortex-m3/nxp/lpc1766/: system_init.c
    ../../ChinaOS/architecture/arm/cortex-m3/nxp/lpc1766/can_repeater/: memory.c device.c
    ../../ChinaOS/architecture/arm/cortex-m3/nvic/: interrupt.c
    X:/ChinaOS/ChinaOS/architecture/arm/cortex-m3/nxp/lpc1766/timer/: timer.c millisecond.c
    ../../ChinaOS/architecture/arm/cortex-m3/nxp/lpc1766/ticker/: ticker.c
    X:/ChinaOS/ChinaOS/architecture/arm/cortex-m3/nxp/lpc1766/can/: can.c can_filter.c can0.c can1.c
    X:/ChinaOS/ChinaOS/architecture/arm/cortex-m3/nxp/lpc1766/uart/: uart.c
    X:/ChinaOS/ChinaOS/architecture/arm/cortex-m3/nxp/lpc1766/uart/uart0/: uart0.c
    X:/ChinaOS/ChinaOS/architecture/arm/cortex-m3/nxp/lpc1766/can_repeater/led2/: led2.c
  group kernel
    ../../ChinaOS/kernel/: kernel.c
    ../../ChinaOS/kernel/semaphore/: semaphore.c
    ../../ChinaOS/kernel/mailbox/: mailbox.c
    ../../ChinaOS/kernel/pipe/: pipe.c
  group library
    ../../ChinaOS/library/sysio/: sysio.c
    ../../ChinaOS/library/bit/: bit.c
    ../../ChinaOS/library/malloc/: malloc.c
    ../../ChinaOS/library/: printk.c
    ../../ChinaOS/library/console/: console.c commmand.c
  group include
    ../../ChinaOS/include/: ChinaOS.h debug.h macro.h types.h
  group home
    ./home/: main.c
    ./home/thread_1/: thread_1.c
    ./home/thread_2/: thread_2.c
target ChinaOS(release) (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: hello
  c flags: Optim=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ..\..\ChinaOS\architecture\arm\cortex-m3\nxp\lpc1766\can_repeater\load\release.scf
  link misc: --entry=main --keep=boot.o(Heap) --keep=boot.o(Stack)

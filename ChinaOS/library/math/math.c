/******************************************************Copyright (c)**************************************************
**                                              胆怯是阻止一切可能的根本缘由
**
**                                             E-Mail: ChinaFengliang@163.com
**
**---------File Information-------------------------------------------------------------------------------------------
** File name:            math.c
** Last version:         V1.00
** Descriptions:         数学运算库文件.
** Hardware platform:
** SoftWare platform:
**
**--------------------------------------------------------------------------------------------------------------------
** Created by:           Fengliang
** Created date:         2010年11月16日  10:45:5
** Version:              V1.00
** Descriptions:         The original version
**
**--------------------------------------------------------------------------------------------------------------------
** Modified by:
** Modified date:
** Version:
** Descriptions:
**
*********************************************************************************************************************/

/*********************************************************************************************************************
                                                    头文件区
*********************************************************************************************************************/
#include    <include\OS_macro.h>
#include    <include\OS_types.h>
#include    "./math.h"

/*********************************************************************************************************************
                                                    宏定义区
*********************************************************************************************************************/
/* 宏段名 ----------------------------------------------------------------------------------------------------------*/


/*********************************************************************************************************************
                                                    类型定义区
*********************************************************************************************************************/
/* 基本类型 --------------------------------------------------------------------------------------------------------*/


/*********************************************************************************************************************
                                                  全局变量定义区
*********************************************************************************************************************/
char    symbol[] = {'0','1','2','3','4','5','6','7','8','9','A','B','C','D','E','F'};

/*********************************************************************************************************************
** Function name:           get_max_common_divisor
** Descriptions:            获取最大公约数
** Input parameters:        a : 目标数
**                          b : 目标数
** Output parameters:       none
** Returned value:          最大公约数
**--------------------------------------------------------------------------------------------------------------------
** Created by:              Fengliang
** Created Date:            2010-11-16  10:46:7
** Test recorde:            通过测试
**--------------------------------------------------------------------------------------------------------------------
** Modified by:
** Modified date:
** Test recorde:
*********************************************************************************************************************/
INT32U get_max_common_divisor(INT32U a, INT32U b)
{
    INT32U Max, Min;                                                        /* 最大/小数                            */
    INT32U remainder;                                                       /* 余数                                 */

    /* 
     * 参数过滤
     */
    if ((0 == Max) || (0 == Min))
    {
        return 0;
    }

    Max = max(a, b);
    Min = min(a, b);

    do
    {
        remainder = Max % Min;
        Max = Min;
        Min = remainder;
    } while (remainder);

    return Max;
}

/*********************************************************************************************************************
** Function name:           factorial
** Descriptions:            n的阶乘
** Input parameters:        n : 数
** Output parameters:       
** Returned value:          阶乘和
**--------------------------------------------------------------------------------------------------------------------
** Created by:              Feng Liang
** Created Date:            2011-12-5  13:17:1
** Test recorde:            
**--------------------------------------------------------------------------------------------------------------------
** Modified by:
** Modified date:
** Test recorde: 
*********************************************************************************************************************/
unsigned int factorial(unsigned int n)
{
    if (0 == n)
    {
        return 0;
    }

    return n + factorial(n-1);
}

/*********************************************************************************************************************
** Function name:           binary_search
** Descriptions:            折半查找法
** Input parameters:        aSource : 数据组
**                          Max     : 数据数目
**                          Key     : 目标数
** Output parameters:       
** Returned value:          !=-1 : 操作成功(包含数组索引)
**                          ==-1 : 操作失败
**--------------------------------------------------------------------------------------------------------------------
** Created by:              Feng Liang
** Created Date:            2012-3-30  12:44:51
** Test recorde:            
**--------------------------------------------------------------------------------------------------------------------
** Modified by:
** Modified date:
** Test recorde: 
*********************************************************************************************************************/
int binary_search(int aSource[], int Max, int Key)
{
    int             Left, Middle, Right;


    Left  = 0;
    Right = Max;

    while (Left <= Right)
    {
        int         Value;

        Middle = (Right - Left) >> 1;                                       
        Value  = aSource[Middle];
        if (Key == Value)
        {
            return Middle;
        }
        
        if (Value < Key)
        {
            Left  = Middle + 1;
        }
        else
        {
            Right = Middle - 1;
        }
        
    }
    return -1;
}

/*********************************************************************************************************************
** Function name:           itox
** Descriptions:            将整型数转换成16进制字符串
** Input parameters:        x : 整型数
** Output parameters:       pBuffer : 输出字符串
** Returned value:         
**--------------------------------------------------------------------------------------------------------------------
** Created by:              Fengliang
** Created Date:            2011-3-7  12:40:7
** Test recorde:            
**--------------------------------------------------------------------------------------------------------------------
** Modified by:
** Modified date:
** Test recorde: 
*********************************************************************************************************************/
#if 0
void itox(char *pBuffer, int x)
{
    int         i;

    for (i = (sizeof(int) << 1) -1; 0 <= i; i--)
    {
        pBuffer[7-i] = symbol[(x>>(i<<2)) & 0x0F];
    }
}

int xtoi(char *pString)
{
    int         i;
    int         Result;
    
    for (i = 0; i < (sizeof(int)<<1); i++)
    {
        
    }
}
#endif
/*********************************************************************************************************************
                                                    END OF FILE
*********************************************************************************************************************/

